# Keil uVision project PY108xx_Flash.uvprojx, settings and files
target PY108xx_24 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: PY32F005x6 Puya
  pack: Puya.PY32F0xx_DFP.1.2.15
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00008000) IROM2(0x1FFF0080,0x00000010) XROM(0x1FFF0280,0x00000080) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: PY108xx_24
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: FLASH_MEM PY108xx_24
  memory RVCT1: ROM 0x1fff0280 size 0x80
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT5: ROM 0x1fff0080 size 0x10
  memory RVCT9: RAM 0x20000000 size 0xc00
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target PY108xx_32 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: PY32F005x6 Puya
  pack: Puya.PY32F0xx_DFP.1.2.15
  cpu: as above
  output: PY108xx_32
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: FLASH_MEM PY108xx_32
  memory RVCT1: ROM 0x1fff0280 size 0x80
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT5: ROM 0x1fff0080 size 0x10
  memory RVCT9: RAM 0x20000000 size 0xc00
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target FLASH_OB (6240000::V6.24::ARMCLANG)
  device: PY32F005x6 Puya
  pack: Puya.PY32F0xx_DFP.1.2.15
  cpu: as above
  output: PY108xx_OB
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: FLASH_OB
  memory RVCT1: ROM 0x1fff0280 size 0x80
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT5: ROM 0x1fff0080 size 0x10
  memory RVCT9: RAM 0x20000000 size 0xc00
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target FLASH_OTP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: PY32F005x6 Puya
  pack: Puya.PY32F0xx_DFP.1.2.15
  cpu: as above
  output: PY108xx_OTP
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: FLASH_MEM FLASH_OTP
  memory RVCT1: ROM 0x1fff0280 size 0x80
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT5: ROM 0x1fff0080 size 0x10
  memory RVCT9: RAM 0x20000000 size 0xc00
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
