# Keil uVision project PY068xx_Flash.uvprojx, settings and files
target PY068xx_12 (6220000::V6.22::ARMCLANG)
  device: PY32T020x6 Puya
  pack: Puya.PY32T0xx_DFP.1.0.9
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: PY068xx_12
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: FLASH_MEM PY068xx_12
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target PY068xx_16 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: PY32T020x6 Puya
  pack: Puya.PY32T0xx_DFP.1.0.9
  cpu: as above
  output: PY068xx_16
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: FLASH_MEM PY068xx_16
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target PY068xx_20 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: PY32T020x6 Puya
  pack: Puya.PY32T0xx_DFP.1.0.9
  cpu: as above
  output: PY068xx_20
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: FLASH_MEM PY068xx_20
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target PY068xx_24 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: PY32T020x6 Puya
  pack: Puya.PY32T0xx_DFP.1.0.9
  cpu: as above
  output: PY068xx_24
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: FLASH_MEM PY068xx_24
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target PY068xx_32 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: PY32T020x6 Puya
  pack: Puya.PY32T0xx_DFP.1.0.9
  cpu: as above
  output: PY068xx_32
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: FLASH_MEM PY068xx_32
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target FLASH_OB (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: PY32T020x6 Puya
  pack: Puya.PY32T0xx_DFP.1.0.9
  cpu: as above
  output: PY068xx_OB
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: FLASH_OB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target FLASH_OTP (6220000::V6.22::ARMCLANG)
  device: PY32T020x6 Puya
  pack: Puya.PY32T0xx_DFP.1.0.9
  cpu: as above
  output: PY068xx_OTP
  AfterMake: cmd.exe /C copy "!L" ".\Out\@L.FLM"
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: FLASH_MEM FLASH_OTP
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
software components: CMSIS:CORE 6.2.0
